# Keil uVision project iSO-STM32.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SUB +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\W5500;..\..\User\app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_i2c.c stm32f10x_can.c stm32f10x_iwdg.c
  group USER
    ../../User/: main.c system.h stm32f10x_it.c
    ../../User/app/: usart.c usart.h adc.c adc.h can.c can.h rs485.c rs485.h timer.c timer.h wdg.c wdg.h
  group W5500
    ../../User/W5500/: w5500.c w5500_conf.c socket.c utility.c
  group APP
    ../../User/app/: 24c02.c 24c02.h led.c led.h ds18b20.c ds18b20.h calibration.c
  group README
    ../../: readme.txt
