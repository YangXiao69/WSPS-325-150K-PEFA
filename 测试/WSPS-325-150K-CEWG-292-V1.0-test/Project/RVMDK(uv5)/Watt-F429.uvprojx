# Keil uVision project Watt-F429.uvprojx, settings and files
target InFlash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: USART +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\User;..\..\User\app;..\..\User\bsp;..\..\User\RFE001;..\..\User\W5500
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ../../User/: main.c stm32f4xx_it.c
    ../../User/app/control/: control.c
    ../../User/app/lcd/: lcd.c
    ../../User/app/network/: network.c
    ../../User/app/remote/: remote.c
    ../../User/app/settings/: settings.c
  group Bsp
    ../../User/bsp/: bsp.c
    ../../User/bsp/bsp_adc/: bsp_adc.c
    ../../User/bsp/bsp_adf4351/: bsp_adf4351.c
    ../../User/bsp/bsp_dac/: bsp_dac.c
    ../../User/bsp/bsp_ds18b20/: bsp_ds18b20.c
    ../../User/bsp/bsp_eeprom/: bsp_i2cee.c
    ../../User/bsp/bsp_led/: bsp_led.c
    ../../User/bsp/bsp_timer/: bsp_general_timer.c
    ../../User/bsp/bsp_usart/: bsp_usart.c
    ../../User/bsp/bsp_spiflash/: bsp_w25q64.c
  group W5500
    ../../User/W5500/: w5500_conf.c w5500.c socket.c
  group RFE001
    ../../User/RFE001/: RFE001.c Volcano.c
  group Doc
    ../../: readme.txt
  group IAP
    ../../User/ymodem/: flash_if.c
