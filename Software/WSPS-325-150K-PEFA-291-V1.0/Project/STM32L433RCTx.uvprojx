# Keil uVision project STM32L433RCTx.uvprojx, settings and files
target STM32L433RCTx (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L433RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L433RCTx +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L433xx
  c include: ..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\Drivers\STM32L4xx_HAL_Driver\Inc;..\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../User/: system_stm32l4xx.c
  group Application/MDK-ARM
    ../User/: startup_stm32l433xx.s
  group Application/User
    ../User/: stm32l4xx_hal_msp.c stm32l4xx_it.c main.c
    ../User/app/monitor/: monitor.c
    ../User/app/network/: network.c
    ../User/app/settings/: settings.c
  group Application/Bsp
    ../User/bsp/: bsp.c
    ../User/bsp/bsp_adc/: bsp_adc.c
    ../User/bsp/bsp_ds18b20/: bsp_ds18b20.c
    ../User/bsp/bsp_eeprom/: bsp_at24c02.c
    ../User/bsp/bsp_spi/: bsp_spi.c
    ../User/bsp/bsp_gpio/: bsp_gpio.c
  group Application/W5500
    ../User/W5500/: w5500_conf.c w5500.c socket.c
software components: CMSIS:CORE 4.3.0
